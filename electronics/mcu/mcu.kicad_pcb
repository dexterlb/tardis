# Repository dexterlb/tardis

## KiCad design electronics/mcu/mcu.kicad_pcb

Parts:
C1: 100n; Capacitor7.5MMDiscRM5
C2: 22u; Elko_vert_20x10mm_RM5
C3, C4: 22p; Capacitor7.5MMDiscRM5
IC1: ATTINY2313-S; SO-20-L
P1: 3.3v; Pin_Header_Straight_1x02
P2: CONTROL; Pin_Header_Straight_1x06
P3: PI; Pin_Header_Straight_1x05
P4: EXTRA; Pin_Header_Straight_2x05
R1: 10k; Resistor_Horizontal_RM10mm
R2, R3, R4, R5: 100; R_0805
X1: 8MHz; HC-49V_S

Connections:
GND: C1.2, C2.2, C3.2, C4.2, IC1.10 (GND), P1.2, P2.1, P3.5, P4.2, P4.4, P4.6, P4.8, P4.10, X1.0 (Shield)
unnamed: C1.1, C2.1, IC1.20 (VCC), P1.1, R1.1
unnamed: C3.1, IC1.4 (PA1(XTAL2)), X1.2
unnamed: C4.1, IC1.5 (PA0(XTAL1)), X1.1
unnamed: IC1.1 (PA2(~RESET~/dW)), P3.1, R1.2
unnamed: IC1.2 ((RXD)PD0), R4.2
unnamed: IC1.3 ((TXD)PD1), R5.2
unnamed: IC1.6 ((CKOUT/XCK/INT0)PD2), P4.1
unnamed: IC1.7 ((INT1)PD3), P4.3
unnamed: IC1.8 ((T0)PD4), P4.5
unnamed: IC1.9 ((OC0B/T1)PD5), P4.7
unnamed: IC1.11 ((ICP)PD6), P4.9
unnamed: IC1.12 ((PCINT0/AIN0)PB0), P2.2
unnamed: IC1.13 ((PCINT1/AIN1)PB1), P2.3
unnamed: IC1.14 ((PCINT2/OC0A)PB2), P2.4
unnamed: IC1.15 ((PCINT3/OC1A)PB3), P2.5
unnamed: IC1.16 ((PCINT4/OC1B)PB4), P2.6
unnamed: IC1.17 ((PCINT5/MOSI/DI/SDA)PB5), P3.2
unnamed: IC1.18 ((PCINT6/MISO/DO)PB6), R2.2
unnamed: IC1.19 ((PCINT7/USCK/SCK/SCL)PB7), R3.2
unnamed: P3.3, R2.1, R4.1
unnamed: P3.4, R3.1, R5.1

Board: 2 copper layers, 15 parts (5 on the bottom side), 22 nets.

## KiCad design electronics/digital/digital.kicad_pcb

Parts:
BT1: BATTERY; BAT-CR2032
C1, C3: 100u; Capacitor16x25RM7.5
C2, C4: 100n; SMD-1206
C5, C6, C7, C9, C11: 100n; Capacitor6MMDiscRM5
C8: 10p; Capacitor6MMDiscRM5
C10: 10u; Capacitor10x16RM5
D1, D2: LED; Pin_Header_Straight_1x02
D3: TL431; TO92-123
F1: FUSE; Capacitor6MMDiscRM5
J1, J2: USB_A
J3: RJ45; RJ45_8_BIG
L1: INDUCTOR_SMALL; SMD-1206
P1: POWER_IN; BARREL_JACK
P2: 3V3_IN; Pin_Header_Straight_1x02
P3, P4: USB_CABLE; Pin_Header_Straight_1x03
P5: NETWORK_CABLE; RJ45_SOLDER
P6: EXTERNAL_HEADER; Pin_Header_Angled_2x05
P7: POWER_OUT; Pin_Header_Straight_2x05
P8: INTERNAL_HEADER; Pin_Header_Straight_2x05
P9: I2C 1; Pin_Header_Straight_1x02
P10: AMP_POWER_OUT; Pin_Header_Straight_1x02
P11: CONTROL
P12: ADC_SPI; Pin_Header_Straight_1x04
P13: I2C 2; Pin_Header_Straight_1x02
Q1, Q2, Q5: MOS_P_123; sot23
Q3, Q4, Q6, Q7, Q9: NPN; TO92-123
Q8: MOSFET_N; DPAK-2-1EP_GDS
Q10: PNP; TO92-123
R1, R2, R11: 1; Resistor_Horizontal_RM10mm
R3, R4, R9, R10, R12, R14: 10k; Resistor_Horizontal_RM10mm
R5, R6, R15, R20: 1k; Resistor_Horizontal_RM10mm
R7, R8, R16, R17, R21: 4.7k; Resistor_Horizontal_RM10mm
R13: Photores; Pin_Header_Straight_1x02
R18: 2.2k; Resistor_Horizontal_RM10mm
R19: 10; Resistor_Horizontal_RM10mm
R22: 560; Resistor_Horizontal_RM10mm
R23: 0; Resistor_Horizontal_RM10mm
R24: DNP; Resistor_Horizontal_RM10mm
U1: DS1307+; SO-8
U2: MCP3001; SO-8
X1: 32.768MHz; QMONTRE_P

Connections:
+3.3VP: C5.1, P2.1, P7.1, P7.3, R9.1, R10.1, R12.1, R22.1, U2.8
+5V: C1.1, C2.1, C6.1, C7.1, F1.2, J1.1 (Vbus), J2.1 (Vbus), L1.1, P7.5, P7.7, P7.9, Q5.2 (S), R14.2, U1.8 (VCC)
/AMP_SEL: P11.4, R15.2
/LED_PWM: P11.1, R20.2
/LED_SEL_1: P11.2, R6.2
/LED_SEL_2: P11.3, R5.2
/LED_VCC: C3.1, C4.1, L1.2, Q1.2 (S), Q2.2 (S), Q7.3 (C), R3.2, R4.2, R16.2
/SCL: P9.1, P13.1, R9.2, U1.6 (SCL)
/SDA: P9.2, P13.2, R10.2, U1.5 (SDA)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, D3.3, J1.4 (GND), J1.5 (Sh_1), J1.6 (Sh_2), J2.4 (GND), J2.5 (Sh_1), J2.6 (Sh_2), J3.9 (SHIELD), P1.2, P2.2, P3.3, P4.3, P7.2, P7.4, P7.6, P7.8, P7.10, P10.2, P11.5, P12.4, Q3.1 (E), Q4.1 (E), Q6.1 (E), Q8.S, Q9.1 (E), Q10.3 (C), R7.1, R8.1, R13.2, R17.1, R21.1, R24.2, U1.4 (GND), U2.3, U2.4, X1.0 (Shield); also elsewhere on the board
unnamed: BT1.1 (+), U1.3 (VBAT)
unnamed: C8.1, U1.2 (XTAL2), X1.2
unnamed: C8.2, U1.1 (XTAL1), X1.1
unnamed: C9.1, R12.2, R13.1, U2.2
unnamed: C10.1, C11.1, D3.1, R22.2, R23.1, U2.1
unnamed: D1.1 (A), Q2.3 (D)
unnamed: D1.2 (K), R2.2
unnamed: D2.1 (A), Q1.3 (D)
unnamed: D2.2 (K), R1.1
unnamed: D3.2, R23.2, R24.1
unnamed: F1.1, P1.1
unnamed: J1.2 (D-), P3.1
unnamed: J1.3 (D+), P3.2
unnamed: J2.2 (D-), P4.1
unnamed: J2.3 (D+), P4.2
unnamed: J3.1, P5.8
unnamed: J3.2, P5.7
unnamed: J3.3, P5.6
unnamed: J3.4, P5.5
unnamed: J3.5, P5.4
unnamed: J3.6, P5.3
unnamed: J3.7, P5.2
unnamed: J3.8, P5.1
unnamed: P6.1, P8.2
unnamed: P6.2, P8.1
unnamed: P6.3, P8.4
unnamed: P6.4, P8.3
unnamed: P6.5, P8.6
unnamed: P6.6, P8.5
unnamed: P6.7, P8.8
unnamed: P6.8, P8.7
unnamed: P6.9, P8.10
unnamed: P6.10, P8.9
unnamed: P10.1, R11.1
unnamed: P12.1, U2.5
unnamed: P12.2, U2.6
unnamed: P12.3, U2.7
unnamed: Q1.1 (G), Q3.3 (C), R3.1
unnamed: Q2.1 (G), Q4.3 (C), R4.1
unnamed: Q3.2 (B), R5.1, R7.2
unnamed: Q4.2 (B), R6.1, R8.2
unnamed: Q5.1 (G), Q6.3 (C), R14.1
unnamed: Q5.3 (D), R11.2
unnamed: Q6.2 (B), R15.1, R17.2
unnamed: Q8.D, R1.2, R2.1
unnamed: Q8.G, R19.1
unnamed: Q9.2 (B), R20.1, R21.2
unnamed: Q9.3 (C), R16.1, R18.2
unnamed: Q7.1 (E), Q10.1 (E), R19.2
unnamed: Q7.2 (B), Q10.2 (B), R18.1

Board: 2 copper layers, 76 parts (9 on the bottom side), 60 nets.

Other parts of the board:
1pin, 1pin#2, 1pin#3, 1pin#4, 1pin#5, 1pin#6: VAL**; 1pin

Their connections:
GND: 1pin.1, 1pin#2.1, 1pin#3.1, 1pin#4.1, 1pin#5.1, 1pin#6.1; also elsewhere on the board

## Commit log

2015-02-28 add shell scripts
2015-02-28 add media files
2015-02-28 add dns.rb
2015-02-28 add nokogiri
2015-02-28 make dns.rb executable
2015-02-28 add gitignore
2015-02-28 implement recognizing new devices
2015-02-28 add reload_dns
2015-02-28 reverse order of hostnames
2015-02-28 user-friendly connect notification
2015-02-28 set timeout to 2.5sec
2015-02-28 remove old monitor script
2015-02-28 remove router_url
2015-02-28 simplify update
2015-02-28 remove sensitive data
2015-02-28 uncomment logfile
2015-03-01 bugfix: zombie threads when wooshing
2015-03-04 start rewriting code from ruby to python
2015-03-04 monitoring works
2015-03-04 fuck ruby
2015-03-04 add hashbang
2015-03-04 change woosh sound
2015-03-18 move scripts to run/ subfolder
2015-03-18 add schematics
2015-03-19 add filters and amplifier schematic
2015-03-19 add led and rj45
2015-03-20 split into digital and analogue parts
2015-03-20 add led to power
2015-03-21 add second led
2015-03-21 split led resistors
2015-03-21 add ds1307
2015-03-22 updated to master
2015-03-22 move electronics to subfolder
2015-03-22 no more govnokod
2015-03-23 change OpenStruct to Struct
2015-03-23 simplify struct
2015-03-23 add headers and usb ports
2015-03-23 ran annotation
2015-03-23 fix ERC errors
2015-03-23 add usb schematic
2015-03-23 change to using Net.HTTP
2015-03-23 remove garbage collect line
2015-03-27 add client test file
2015-03-28 add woosh
2015-04-10 sync to pcb
2015-04-10 add rj45
2015-04-11 add fuse
2015-04-12 route led drivers
2015-04-12 arrange transistors
2015-04-12 drivers are all routed
2015-04-12 sort of shaped up
2015-04-19 work on pcb
2015-04-19 placed everything
2015-04-20 add lightmeter to schematic
2015-04-20 fuck 3v3
2015-04-23 finish routing of lightmeter
2015-04-24 fuck.
2015-04-24 working on polygon
2015-04-24 finish polygon
2015-04-27 move some resistors, add holes
2015-04-27 make holes connected to gnd
2015-04-27 prints
2015-04-28 add some GND pads
2015-04-30 fix values of referance voltage regulator
2015-05-15 add hardware.sh
2015-05-15 add primitive hardware functions
2015-05-15 use ogg files
2015-05-17 work on adc
2015-05-17 update adc
2015-05-17 move adc file
2015-05-17 add adc build script
2015-05-17 work on hardware
2015-05-21 now using sox for playing audio
2015-05-24 animate led
2015-05-24 fix float number
2015-06-14 use hwclock
2015-09-10 make wooshing asynchronous so the DNS server doesn't hang while wooshing
2015-09-23 add 3d models
2015-09-24 use tail in lightness()
2015-09-25 ignore backup files
2015-09-26 add push/pop methods for amp_power
2015-09-26 move play to another file
2015-09-26 add light fx for wooshing (incomplete)
2015-09-26 some light data
2015-09-27 remove test case from ip.sh
2015-09-27 I'm so stupid.
2015-09-29 simplify ip.sh
2015-09-30 add mcu board
2015-09-30 add footprints
2015-10-05 some minor tweaks
2015-10-05 add tardis telegram bot
2015-10-05 ignore bak files
2015-10-05 rename tardis_bot
2015-10-05 implement command parsing
2015-10-05 fix newlines
2015-10-06 parse some commands
2015-10-06 parse /spam
2015-10-07 implement spamming
2015-10-08 remove logging (who needs that anyway?)
2015-10-08 get spam from fifo in /tmp
2015-10-08 fix permissions
2015-10-12 finish the pcb
2015-11-25 add mcu source
2015-11-25 add testing firmware
2015-11-25 add remote flashing
2015-11-26 add comment about sshflash
2015-11-26 fix typo
2015-12-29 well, software SPI does work..
2015-12-29 add host tests
2015-12-29 simplify devmem example
2015-12-29 retab!
2015-12-29 hardware SPI works
2016-01-10 add some go code
2016-01-10 add GoPi code
2016-01-10 fix the spi library to support dynamic message sizes
2016-01-10 make code more human-readable
2016-01-20 join uart and spi on the mcu pcb
2016-01-20 move chip select to portd 3
2016-06-27 update 3D model
2017-03-26 use namecheap for IP updating
2017-09-14 add dynamic dns for digital ocean
2017-09-14 use full path to python script
2018-10-13 add skeleton for control project
2018-10-13 don't include erts in production builds
2018-10-13 bump kicad project
2018-10-19 start leddy service correctly
2018-10-20 fix dependencies
2018-10-25 somewhat working bezier
2018-11-28 begin fixing dependencies
2018-11-29 make it work with renamed potoo version
2018-11-29 correctly pull web ui
2019-12-26 add stupid_proto c implementation
2019-12-26 add proto_test
2019-12-26 simple uart communication
2019-12-26 add proto to avr project
2019-12-26 add simple uart
2019-12-26 add wiring document
2019-12-26 use link time optimisation for AVR code
2019-12-26 upgrade avr sconstruct
2020-01-03 add stupid_proto readme
2020-01-03 fix markdown
2020-01-03 comment
2020-01-03 add sync variants for proto functions
2020-01-03 add a golang interface for proto
2020-01-03 fix bug
2020-01-04 fix tests
2022-03-26 some stray changes
2022-03-26 remove digitalocean shit
2022-04-20 add new wiring
